## firmware/boards/harding/cwm_nrf52810/board.yml
```yaml
board:
  name: cwm_nrf52810
  full_name: Custom Wireless Mouse (nRF52810)
  vendor: harding
  socs:
    - name: nrf52810
```
